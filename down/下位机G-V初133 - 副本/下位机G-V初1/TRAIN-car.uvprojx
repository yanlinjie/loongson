# Keil uVision project TRAIN-car.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TRAIN-car
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\STM32F10x_FWLib\inc;.\STM32F10x_FWLib\src;.\USER;.\HARDWARE\motor;.\HARDWARE\uart;.\HARDWARE\JY901;.\HARDWARE\1.69LCD;.\HARDWARE\24CXX;.\HARDWARE\BSP;.\HARDWARE\TIM;.\HARDWARE\usart;.\HARDWARE\usart_init
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group HARDWARE
    ./HARDWARE/uart/: uart_2.c blue.c
    ./HARDWARE/TIM/: TIM.C
    ./SYSTEM/delay/: delay.c
    ./HARDWARE/usart_init/: usart_init.c
  group logic
    ./HARDWARE/uart/: usart_3.c
    ./SYSTEM/sys/: sys.c
    ./HARDWARE/motor/: motor.c
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group extern_ROM
    ./HARDWARE/24CXX/: 24cxx.c
  group LCD
    ./HARDWARE/1.69LCD/: lcd_image.c lcd_fonts.c lcd_spi_169.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
