# Keil uVision project RCT6_template.uvprojx, settings and files
target RCT6_template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x0000C000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RCT6_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --locale=english
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\LobotServo;..\HARDWARE\TIM;..\HARDWARE\USART;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\motor;..\HARDWARE\ArmCamera;..\HARDWARE\QRcode;..\HARDWARE\RGB;..\HARDWARE\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LobotServo/: LobotServoController.c
    ../HARDWARE/TIM/: tim.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/LCD/: lcd_image.c lcd_spi_169.c lcd_fonts.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/ArmCamera/: ArmCamera.c
    ../HARDWARE/QRcode/: fifo.c
    ../HARDWARE/RGB/: WS2812.c
    ../HARDWARE/ESP8266/: EspCommand.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_dma.c
